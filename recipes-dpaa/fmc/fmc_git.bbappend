COMPATIBLE_MACHINE:nxp-ls1046 = "nxp-ls1046"
EXTRA_OEMAKE_PLATFORM:nxp-ls1046 = "ls1046"

