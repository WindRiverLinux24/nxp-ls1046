COMPATIBLE_MACHINE:nxp-ls1046 = "nxp-ls1046"
TARGET_ARCH_FMLIB:nxp-ls1046 = "arm"