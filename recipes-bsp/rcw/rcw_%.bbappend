COMPATIBLE_MACHINE:nxp-ls1046 = "nxp-ls1046"
M:nxp-ls1046 = "ls1046ardb"
