KBRANCH:nxp-ls1046 = "v5.15/standard/nxp-sdk-5.15/nxp-soc"

require linux-yocto-nxp-ls1046.inc
